v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 0 -250 -0 -190 { lab=#net1}
N 30 -160 90 -160 { lab=#net1}
N 120 -250 120 -190 { lab=#net2}
N -370 300 -370 320 { lab=VN}
N 150 -280 190 -280 { lab=#net2}
N 30 -280 50 -280 { lab=#net3}
N 50 -280 50 -240 { lab=#net3}
N 50 -240 220 -240 { lab=#net3}
N 220 -250 220 -240 { lab=#net3}
N 220 -240 220 -190 { lab=#net3}
N -0 -330 -0 -310 { lab=VP}
N 120 -330 120 -310 { lab=VP}
N 220 -330 220 -310 { lab=VP}
N 250 -160 310 -160 { lab=#net4}
N 290 -210 290 -160 { lab=#net4}
N 290 -210 340 -210 { lab=#net4}
N 340 -210 340 -190 { lab=#net4}
N 340 -250 340 -210 { lab=#net4}
N 220 -240 280 -240 { lab=#net3}
N 280 -240 290 -240 { lab=#net3}
N 290 -280 290 -240 { lab=#net3}
N 290 -280 310 -280 { lab=#net3}
N 340 -330 340 -310 { lab=VP}
N 310 -280 420 -280 { lab=#net3}
N 420 -280 530 -280 { lab=#net3}
N 450 -330 450 -310 { lab=VP}
N 560 -330 560 -310 { lab=VP}
N 450 -250 450 -190 { lab=Vg}
N 450 -210 500 -210 { lab=Vg}
N 500 -210 500 -160 { lab=Vg}
N 480 -160 500 -160 { lab=Vg}
N 560 -250 560 -190 { lab=Vbn}
N 560 -210 590 -210 { lab=Vbn}
N 590 -210 590 -160 { lab=Vbn}
N 450 -130 450 -100 { lab=#net5}
N 480 -110 480 -70 { lab=#net5}
N 450 -110 480 -110 { lab=#net5}
N 590 -160 640 -160 { lab=Vbn}
N 500 -160 540 -160 { lab=Vg}
N 540 -230 540 -160 { lab=Vg}
N 540 -230 640 -230 { lab=Vg}
N 560 -130 560 -120 { lab=#net6}
N 520 -90 530 -90 { lab=VP}
N 520 -330 520 -90 { lab=VP}
N 120 -330 560 -330 { lab=VP}
N 0 -370 -0 -330 { lab=VP}
N -370 330 -370 360 { lab=VN}
N 120 -420 120 -330 { lab=VP}
N 0 -420 120 -420 { lab=VP}
N 120 -130 120 -30 { lab=VN}
N 220 -130 220 -30 { lab=VN}
N 450 -40 450 -30 { lab=VN}
N 560 -60 560 -30 { lab=VN}
N 120 -250 160 -250 { lab=#net2}
N 160 -280 160 -250 { lab=#net2}
N 340 -130 340 -30 { lab=VN}
N -0 -420 -0 -370 { lab=VP}
N -40 -420 -0 -420 { lab=VP}
N 30 -190 30 -160 { lab=#net1}
N 0 -190 30 -190 { lab=#net1}
N -100 -420 -100 -170 { lab=VP}
N -100 -420 -40 -420 { lab=VP}
N -120 -420 -100 -420 { lab=VP}
N -0 310 120 310 { lab=VN}
N 120 -30 120 310 { lab=VN}
N 220 -30 220 300 { lab=VN}
N 220 300 220 310 { lab=VN}
N 120 310 220 310 { lab=VN}
N 340 -30 340 300 { lab=VN}
N 220 310 340 310 { lab=VN}
N 340 300 340 310 { lab=VN}
N 450 -30 450 310 { lab=VN}
N 340 310 450 310 { lab=VN}
N 560 -30 560 310 { lab=VN}
N 450 310 560 310 { lab=VN}
N -100 110 -100 140 { lab=VP}
N -100 80 -100 110 { lab=VP}
N -100 50 -100 80 { lab=VP}
N -100 20 -100 50 { lab=VP}
N -100 -10 -100 20 { lab=VP}
N -100 -40 -100 -10 { lab=VP}
N -100 -70 -100 -40 { lab=VP}
N -130 -40 -130 -10 { lab=#net7}
N -130 -10 -130 20 { lab=#net7}
N -130 20 -130 50 { lab=#net7}
N -130 50 -130 80 { lab=#net7}
N -130 80 -130 110 { lab=#net7}
N -130 110 -130 140 { lab=#net7}
N -130 140 -130 170 { lab=#net7}
N -70 140 -70 170 { lab=#net8}
N -70 110 -70 140 { lab=#net8}
N -70 80 -70 110 { lab=#net8}
N -70 50 -70 80 { lab=#net8}
N -70 20 -70 50 { lab=#net8}
N -70 -10 -70 20 { lab=#net8}
N -70 -40 -70 -10 { lab=#net8}
N -130 310 0 310 { lab=VN}
N -350 -190 -320 -190 { lab=#net9}
N -320 -190 -290 -190 { lab=#net9}
N -290 -190 -260 -190 { lab=#net9}
N -260 -190 -230 -190 { lab=#net9}
N -230 -190 -200 -190 { lab=#net9}
N -200 -190 -170 -190 { lab=#net9}
N -320 -160 -290 -160 { lab=#net10}
N -290 -160 -260 -160 { lab=#net10}
N -260 -160 -230 -160 { lab=#net10}
N -230 -160 -200 -160 { lab=#net10}
N -200 -160 -170 -160 { lab=#net10}
N -170 -160 -140 -160 { lab=#net10}
N -350 -130 -320 -130 { lab=#net11}
N -320 -130 -290 -130 { lab=#net11}
N -290 -130 -260 -130 { lab=#net11}
N -260 -130 -230 -130 { lab=#net11}
N -230 -130 -200 -130 { lab=#net11}
N -200 -130 -170 -130 { lab=#net11}
N -370 320 -370 330 { lab=VN}
N -130 170 -130 230 { lab=#net7}
N -100 -170 -100 -70 { lab=VP}
N -140 -160 30 -160 {}
N -170 -190 0 -190 {}
N -370 310 -130 310 {}
N -130 290 -130 310 {}
N -370 -130 -370 300 {}
N -370 -130 -350 -130 {}
N -170 -130 -0 -130 {}
C {madvlsi/pmos3.sym} 0 -280 0 1 {name=M1
L=4
W=.75
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 0 -160 0 1 {name=M2
L=4
W=.75
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 120 -160 0 0 {name=M3
L=4
W=.75
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 120 -280 0 1 {name=M4
L=4
W=.75
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/resistor.sym} -130 260 0 0 {name=R1
value=1k
m=1}
C {madvlsi/pmos3.sym} 220 -280 0 0 {name=M5
L=4
W=.75
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 220 -160 0 1 {name=M6
L=4
W=.75
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 340 -160 0 0 {name=M7
L=4
W=.75
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 340 -280 0 0 {name=M8
L=4
W=.75
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 450 -280 0 0 {name=M9
L=4
W=.75
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 560 -280 0 0 {name=M10
L=4
W=.75
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 450 -160 0 1 {name=M11
L=4
W=.75
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 560 -160 0 1 {name=M12
L=4
W=.75
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 450 -70 0 1 {name=M13
L=4
W=.75
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 560 -90 0 0 {name=M14
L=4
W=.75
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/iopin.sym} -120 -420 0 1 {name=p2 lab=VP}
C {devices/iopin.sym} -370 360 0 1 {name=p3 lab=VN}
C {devices/opin.sym} 640 -230 0 0 {name=p4 lab=Vg}
C {devices/opin.sym} 640 -160 0 0 {name=p5 lab=Vbn}
C {madvlsi/nmos3.sym} -100 50 1 0 {name=M15
L=4
W=.75
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -100 20 1 0 {name=M16
L=4
W=.75
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -100 -10 1 0 {name=M17
L=4
W=.75
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -100 -40 1 0 {name=M18
L=4
W=.75
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -100 170 1 0 {name=M19
L=4
W=.75
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -100 140 1 0 {name=M20
L=4
W=.75
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -100 110 1 0 {name=M21
L=4
W=.75
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -100 80 1 0 {name=M22
L=4
W=.75
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -170 -160 0 1 {name=M23
L=4
W=.75
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -200 -160 0 1 {name=M24
L=4
W=.75
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -230 -160 0 1 {name=M25
L=4
W=.75
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -260 -160 0 1 {name=M26
L=4
W=.75
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -290 -160 0 1 {name=M27
L=4
W=.75
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -320 -160 0 1 {name=M28
L=4
W=.75
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -350 -160 0 1 {name=M29
L=4
W=.75
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
